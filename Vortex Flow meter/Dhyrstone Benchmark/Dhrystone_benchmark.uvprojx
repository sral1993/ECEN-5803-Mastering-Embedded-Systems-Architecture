# Keil uVision project Dhrystone_benchmark.uvprojx, settings and files
target Dhrystone_benchmark (ARM-ADS)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.pdsc
  cpu: CPUTYPE("Cortex-M0+")
  output: Dhrystone_benchmark
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_PORTOUT=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KLXX -D__CORTEX_M0PLUS -DDEVICE_SEMIHOST=1 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_SLEEP=1 -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_M0P -DDEVICE_SPISLAVE=1 -DTARGET_KL25Z -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DTARGET_LIKE_CORTEX_M0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DARM_MATH_CM0PLUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_I2CSLAVE=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_BUILD_TIMESTAMP=1508440769.64 -DDEVICE_SERIAL=1 -DTARGET_CORTEX -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS --cpu=Cortex-M0 -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed/.; mbed/TARGET_KL25Z; mbed/TARGET_KL25Z/TARGET_Freescale; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX; mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z; mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M0PLUS,-DARM_MATH_CM0PLUS
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: --show_full_path
  group Dhrystone_benchmark
    ./: dhry.cpp dhry.h main.cpp mbed_config.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h error.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_debug.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar mbed_overrides.o retarget.o startup_MKL25Z4.o sys.o system_MKL25Z4.o
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/: clk_freqs.h gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_KL25Z/: cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h MKL25Z4.h system_MKL25Z4.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/: device.h PeripheralNames.h PinNames.h
